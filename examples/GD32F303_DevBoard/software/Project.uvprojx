# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Utilities;.\Application\Include;.\Utilities\LED;.\Utilities\PWM;.\Utilities\TIMER4;.\Utilities\USART;.\Utilities\AS5600;.\Utilities\I2C;.\Utilities\ADC;.\Utilities\KEY;.\Utilities\SHUTOFF;..\..\..\core\include\LS_Config;..\..\..\core\include\L1_Orchestration;..\..\..\core\include\L2_Core\Business;..\..\..\core\include\L3_Hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./Application/Source/: main.c app_key.c app_boost_monitor.c gd32f30x_it.c systick.c
  group L1_Orchestration
    ../../../core/src/L1_Orchestration/: boost_control.c
  group L2_Core
    ../../../core/src/L2_Core/Business/: incremental_pi.c
  group L3_Hal
    ../../../core/src/L3_Hal/: duty_control.c adc_measurement.c control_timer.c status_indicator.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Utilities
    ./Utilities/LED/: LED.c
    ./Utilities/PWM/: pwm.c
    ./Utilities/TIMER4/: timer4.c
    ./Utilities/USART/: usart.c usart2.c
    ./Utilities/AS5600/: as5600.c
    ./Utilities/I2C/: i2c.c
    ./Utilities/ADC/: adc.c
    ./Utilities/KEY/: key.c
    ./Utilities/SHUTOFF/: shutoff.c
